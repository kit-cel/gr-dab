<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>label</key><value>Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>201072000</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_range</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>384</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[1] + [0]*74</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/luca/Desktop/music.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>dab_dab_transmission_frame_mux_bb</key>
<param><key>id</key><value>dab_dab_transmission_frame_mux_bb_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>num_subch</key><value>1</value></param>
<param><key>subch_size</key><value>[84]</value></param>
</block>
<block>
<key>dab_fib_source_b</key>
<param><key>id</key><value>dab_fib_source_b_0</value></param>
<param><key>coutry_ID</key><value>1</value></param>
<param><key>dabplus</key><value>[1]</value></param>
<param><key>data_rate_n</key><value>[14]</value></param>
<param><key>ensemble_label</key><value>"GNU Radio Tune"</value></param>
<param><key>transmission_mode</key><value>1</value></param>
<param><key>num_subch</key><value>1</value></param>
<param><key>programme_service_labels</key><value>"DABstep         "</value></param>
<param><key>protection_mode</key><value>[2]</value></param>
<param><key>service_comp_lang</key><value>1</value></param>
</block>
<block>
<key>dab_fic_encode</key>
<param><key>id</key><value>dab_fic_encode_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_mp4_encode_sb</key>
<param><key>id</key><value>dab_mp4_encode_sb_0</value></param>
<param><key>afterburner</key><value>1</value></param>
<param><key>samp_rate</key><value>32000</value></param>
<param><key>bit_rate_n</key><value>14</value></param>
<param><key>channels</key><value>2</value></param>
</block>
<block>
<key>dab_msc_encode</key>
<param><key>id</key><value>dab_msc_encode_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>data_rate_n</key><value>14</value></param>
<param><key>protection</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dab_ofdm_mod</key>
<param><key>id</key><value>dab_ofdm_mod_0</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>1. Set frequency and clock source (default is external clock for better performance of the transmitter) in USRP
2. Choose audio source (.wav file or audio source)
3. Add more sub channels (optional)
4. Write Service Info and Multiplex Info in FIB source

Execute "DABstep" out of your terminal for a more user-friendly graphical application</value></param>
<param><key>note</key><value>Instructions:</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>reed_solomon_encode_bb</key>
<param><key>id</key><value>reed_solomon_encode_bb_0</value></param>
<param><key>bit_rate_n</key><value>14</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, 2*samp_rate)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain_range</value></param>
<param><key>clock_rate</key><value>8*samp_rate</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>dab_mp4_encode_sb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>dab_mp4_encode_sb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>dab_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>dab_ofdm_mod_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_dab_transmission_frame_mux_bb_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_fib_source_b_0</source_block_id><sink_block_id>dab_fic_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_fic_encode_0</source_block_id><sink_block_id>dab_dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_mp4_encode_sb_0</source_block_id><sink_block_id>reed_solomon_encode_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_msc_encode_0</source_block_id><sink_block_id>dab_dab_transmission_frame_mux_bb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_ofdm_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reed_solomon_encode_bb_0</source_block_id><sink_block_id>dab_msc_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
